# Keil uVision project ADC_DMA.uvproj, settings and files
target ADC_DMA (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F429ZI STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ADC_DMA
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM32F429I_DISCO,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F429I-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group STM32F429I-Discovery
    ./../../../../Utilities/STM32F429i-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c
  group STM32F4xx_StdPeriph_Driver
    ./../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c
    ../../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_ltdc.c stm32f4xx_sdio.c stm32f4xx_tim.c stm32f4xx_fmc.c stm32f4xx_i2c.c
  group User
    ./../: main.c stm32f4xx_it.c system_stm32f4xx.c
